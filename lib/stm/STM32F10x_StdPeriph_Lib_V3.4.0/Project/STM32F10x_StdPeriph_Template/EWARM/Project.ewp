# IAR project Project.ewp, settings and files
configuration STM32100B-EVAL (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Full.h
  General.OGChipSelectEditMenu: STM32F100xB ST STM32F100xB
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD_VL; USE_STM32100B_EVAL
  ICCARM.CCIncludePath2: ..\; ..\..\..\Libraries\CMSIS\CM3\CoreSupport; ..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\..\Utilities\STM32_EVAL; ..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\Utilities\STM32_EVAL\STM32100B_EVAL
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM3210C-EVAL (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F107xC ST STM32F107xC
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_CL; USE_STM3210C_EVAL
  ICCARM.CCIncludePath2: ..\; ..\..\..\Libraries\CMSIS\CM3\CoreSupport; ..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\..\Utilities\STM32_EVAL; ..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\Utilities\STM32_EVAL\STM3210C_EVAL
configuration STM3210E-EVAL (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F10xxE ST STM32F10xxE
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD; USE_STM3210E_EVAL
  ICCARM.CCIncludePath2: ..\; ..\..\..\Libraries\CMSIS\CM3\CoreSupport; ..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\..\Utilities\STM32_EVAL; ..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\Utilities\STM32_EVAL\STM3210E_EVAL
configuration STM3210B-EVAL (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F10xxB ST STM32F10xxB
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD; USE_STM3210B_EVAL
  ICCARM.CCIncludePath2: ..\; ..\..\..\Libraries\CMSIS\CM3\CoreSupport; ..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\..\Utilities\STM32_EVAL; ..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\Utilities\STM32_EVAL\STM3210B_EVAL
configuration STM32100E-EVAL (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F100xE ST STM32F100xE
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD_VL; USE_STM32100E_EVAL
  ICCARM.CCIncludePath2: ..\; ..\..\..\Libraries\CMSIS\CM3\CoreSupport; ..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\..\Utilities\STM32_EVAL; ..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\Utilities\STM32_EVAL\STM32100E_EVAL
configuration STM3210E-EVAL_XL (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F10xxG ST STM32F10xxG
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_XL; USE_STM3210E_EVAL
  ICCARM.CCIncludePath2: as above
  group CMSIS
    ../../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../: system_stm32f10x.c
  group Doc
    ./: readme.txt
  group EWARMv5
    ../../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_cl.s startup_stm32f10x_hd.s startup_stm32f10x_hd_vl.s startup_stm32f10x_ld.s startup_stm32f10x_ld_vl.s startup_stm32f10x_md.s startup_stm32f10x_md_vl.s startup_stm32f10x_xl.s
  group StdPeriph_Driver
    ../../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_exti.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_usart.c
  group STM32_EVAL
    ../../../Utilities/STM32_EVAL/STM32100B_EVAL/: stm32100b_eval_lcd.c
    ../../../Utilities/STM32_EVAL/STM32100E_EVAL/: stm32100e_eval_lcd.c
    ../../../Utilities/STM32_EVAL/STM3210B_EVAL/: stm3210b_eval_lcd.c
    ../../../Utilities/STM32_EVAL/STM3210C_EVAL/: stm3210c_eval_lcd.c
    ../../../Utilities/STM32_EVAL/STM3210E_EVAL/: stm3210e_eval_lcd.c
    ../../../Utilities/STM32_EVAL/: stm32_eval.c
  group User
    ../: main.c stm32f10x_it.c
